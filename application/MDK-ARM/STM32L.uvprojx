# Keil uVision project STM32L.uvprojx, settings and files
target STM32L (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L071CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L +hex
  AfterMake: fromelf --bin --output .\bin\K8_RI_V1.1.27.bin .\STM32L\STM32L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L071xx
  c include: ../Inc;              ../Drivers/STM32L0xx_HAL_Driver/Inc;              ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;              ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;              ../Drivers/CMSIS/Include;              ..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8007800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../App/: app_kernal.c app_port.c app_sys.c app_user.c app_param.c app_net.c app_task.c app_serverprotocol.c app_gps.c app_gpsrestore.c app_nmea.c app_atcmd.c app_instructioncmd.c app_rec.c app_sn.c app_gpsarithmetic.c app_mir3da.c app_ble.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c i2c.c iwdg.c usart.c rtc.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l071xx.s
    ./STM32L/: STM32L.map
software components: CMSIS:CORE 4.3.0
